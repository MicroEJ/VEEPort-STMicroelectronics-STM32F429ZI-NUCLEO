# IAR project application.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx
  ICCARM.CCIncludePath2: ../main/Inc; ../../../sdk/STM32CubeF4/Drivers/STM32F4xx_HAL_Driver/Inc; ../../../sdk/STM32CubeF4/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../../../sdk/STM32CubeF4/Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../../../sdk/STM32CubeF4/Drivers/CMSIS/Include; ../../../sdk/STM32CubeF4/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../../../sdk/STM32CubeF4/Middlewares/Third_Party/FreeRTOS/Source/include; ../../../sdk/STM32CubeF4/Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ..\config\inc; ..\core\inc; vee_components\inc; ..\..\coremark; ..\validation\port\inc; ..\validation\tests\core\c\inc; ..\validation\framework\c\embunit\embUnit; ..\validation\framework\c\utils\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\config\inc
  OBJCOPY.OOCOutputFile: stm32-nucleo-f429.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Validation (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; VALIDATION
configuration Debug (ARM, debug)
  as the first configuration, except:
  group Application/EWARM
    ./: startup_stm32f429xx.s
  group Application/main
    ../main/src/: main.c putchar.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Drivers/CMSIS
    ../main/src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../sdk/STM32CubeF4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c
  group Microej/config/inc
    ../config/inc/: FreeRTOSConfig.h
  group Microej/core/inc
    ../core/inc/: LLMJVM_FreeRTOS_configuration.h microej_time.h misra_2004_conf.h
  group Microej/core/src
    ../core/src/: fault_handlers.c hooks_FreeRTOS.c LLBSP_generic.c LLMJVM_FreeRTOS.c microej_main.c microej_time.c
  group Microej/validation/coremark/inc
    ../../coremark/: coremark.h
  group Microej/validation/coremark/src
    ../../coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
  group Microej/validation/embunit/inc
    ../validation/framework/c/embunit/embUnit/: AssertImpl.h config.h embUnit.h HelperMacro.h RepeatedTest.h stdImpl.h Test.h TestCaller.h TestCase.h TestListener.h TestResult.h TestRunner.h TestSuite.h
  group Microej/validation/embunit/src
    ../validation/framework/c/embunit/embUnit/: AssertImpl.c RepeatedTest.c stdImpl.c TestCaller.c TestCase.c TestResult.c TestRunner.c TestSuite.c
  group Microej/validation/port/inc
    ../validation/port/inc/: core_portme.h
  group Microej/validation/port/src
    ../validation/port/src/: core_benchmark.c core_portme.c ram_checks.c time_base.c
  group Microej/validation/tests/inc
    ../validation/tests/core/c/inc/: t_core_core_benchmark.h t_core_main.h t_core_print.h t_core_ram.h t_core_time_base.h x_core_benchmark.h x_ram_checks.h x_ram_speed.h x_version.h
  group Microej/validation/tests/src
    ../validation/tests/core/c/src/: t_core_core_benchmark.c t_core_main.c t_core_print.c t_core_ram.c t_core_time_base.c x_impl_core_benchmark.c x_impl_ram_checks.c x_impl_ram_speed.c x_java_testsuite_impl.c x_ram_checks.c x_ram_speed.c
  group Microej/validation/utils/inc
    ../validation/framework/c/utils/inc/: bsp_util.h u_print.h u_time_base.h
  group Microej/validation/utils/src
    ../validation/framework/c/utils/src/: u_print.c u_time_base.c
  group Microej/vee_components/inc
    vee_components/inc/: BESTFIT_ALLOCATOR.h BESTFIT_ALLOCATOR_impl.h LLBSP_impl.h LLKERNEL_impl.h LLMJVM.h LLMJVM_impl.h LLMJVM_MONITOR_impl.h LLTRACE.h LLTRACE_impl.h MJVM_MONITOR.h MJVM_MONITOR_types.h sni.h
  group Microej/vee_components/lib
    vee_components/lib/: microejapp.o microejruntime.a
  group Third_Party/FreeRTOS/Source
    ../../../sdk/STM32CubeF4/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Third_Party/FreeRTOS/Source/CMSIS_RTOS
    ../../../sdk/STM32CubeF4/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.h
  group Third_Party/FreeRTOS/Source/include
    ../../../sdk/STM32CubeF4/Middlewares/Third_Party/FreeRTOS/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group Third_Party/FreeRTOS/Source/portable/IAR
    ../../../sdk/STM32CubeF4/Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c
  group Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4
    ../../../sdk/STM32CubeF4/Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: portasm.s portmacro.h
  group Third_Party/FreeRTOS/Source/portable/MemMang
    ../../../sdk/STM32CubeF4/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
